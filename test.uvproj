# Keil uVision project test.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, HSE_VALUE=8000000
  c include: .;C:\STM32F4xx_DSP_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Include;C:\STM32F4xx_DSP_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;C:\STM32F4xx_DSP_StdPeriph_Lib_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: stm32f4xx_conf.h startup_stm32f4xx.s system_stm32f4xx.c
  group Source Files
    ./: main.c stm32f4xx_it.c
  group Lib
    C:/STM32F4xx_DSP_StdPeriph_Lib_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
target Ram (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, HSE_VALUE=8000000, VECT_TAB_SRAM
  c misc: --cpp
  c include: C:\STM32F4xx_DSP_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Include;C:\STM32F4xx_DSP_StdPeriph_Lib_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;.
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Simulator (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, HSE_VALUE=8000000
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
